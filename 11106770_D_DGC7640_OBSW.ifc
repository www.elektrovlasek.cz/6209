Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2020-01-08T09:01:44
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170419_0315(x64) - Exporter 17.0.1128.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 08 09:01:44 2020 * Host: DEGTL09122 * Database: C:\Users\deschvi\AppData\Local\Temp\{DF2FD6BA-4235-4281-AB12-C2A56DBCA7D3}\ifc * Database version: 5507 * Database creation date: Wed Jan 08 09:01:43 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 08 09:01:44 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 08 09:01:44 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 23764022_D_11106770_DGC7640_OBSW, 11106770_D_DGC7640_OBSW:23764022_D_11106770_DGC7640_OBSW:205682
In: Level 1
Type - Material: z_Miele_Design_Zinc_Steel, z_Miele_Connection_Electric, z_Miele_Design_Steel_Chrom, z_Miele_Design_OBSW
Pset_BuildingElementProxyCommon - Reference: 23764022_D_11106770_DGC7640_OBSW
Pset_ManufacturerTypeInformation - Manufacturer: Miele
